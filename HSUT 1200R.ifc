Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2018-11-01T16:06:36
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 23.0.13600.0000 - Exporter 19.0.0.401 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Nov 01 16:06:36 2018 * Host: DESKTOP-AKA7PPN * Database: C:\Users\DEANJO~1\AppData\Local\Temp\{B049477B-F053-4E3A-9B49-D231A990B2E5}\ifc * Database version: 5507 * Database creation date: Thu Nov 01 16:06:34 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Nov 01 16:06:35 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Nov 01 16:06:35 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcBuildingElementProxy: Standard, Family1:Standard:201980
In: Level 1
Type - Material: 199_199_196
Type - Dimensions - Connector_1_Diameter: 49 mm
Type - Identity Data - Description: HTM64 Scrub Up Trough; Manufacturer: Pland Stainless; Model: HSUT 1200R; OmniClass Number: 23.45.00.00; OmniClass Title: Sanitary, Laundry, and Cleaning Equipment; Type Name: Standard; URL: www.plandstainless.co.uk
Type - Model Properties - Category: Healthcare; COBie AssetType: Fixed; COBie BarCode: 5060021238337; COBie Description: HTM64 Scrub up Trough; COBie DocumentationLiterature: www.plandstainless.co.uk; COBie DurationUnit: Years; COBie ExpectedLife: 30; COBie Features: Right Hand Waste; COBie Finish: Satin/polished; COBie Grade: 304 1.4301; COBie Manufacturer: Plandstainless Ltd; COBie Material: Stainless Steel; COBie Model: Trinidad; COBie ModelNumber: HSUT1200R; COBie Size: 1200 x 400mm; COBie WarrantyDescription: Manufacturer's Warranty; COBie WarrantyDurationUnit: Years; COBie WarrantyDurrationParts: 2; COBie WarrantyGuarantorParts: YES; Company: Pland Stainless; Date Created: 01/11/2018 15:55:00; Designer: DeanJohnson; Design Status: 3; Part Number: HSUT 1200R; Title: HSUT 1200R
Type - Other - Category: Specialty Equipment; Family Name: Family1
Pset_BuildingElementProxyCommon - Reference: Standard
Pset_ManufacturerTypeInformation - Manufacturer: Pland Stainless
Constraints - Offset: 0 mm
Dimensions - Area: 1.37691 m2; Volume: 0.00744983 m3
Other - Family: Family1: Standard; Family and Type: Family1: Standard; Type: Family1: Standard; Type Id: Family1: Standard
Phasing - Phase Created: New Construction
